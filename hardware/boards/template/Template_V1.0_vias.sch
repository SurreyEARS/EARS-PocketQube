File: hardware/boards/template/Template_V1.0_vias.sch (EAGLE design)
At the start: 2 parts

Commit message: fixed fx8c symbols
